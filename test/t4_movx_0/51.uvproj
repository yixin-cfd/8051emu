# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F510 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test.a51
