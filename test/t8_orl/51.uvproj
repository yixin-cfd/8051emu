# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51SL Intel
  cpu: IRAM(0-0xFF) CLOCK(16000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test.a51
